# Keil uVision project GET_UW_PROJ.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GET_UW_PROJ
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\USER;..\BSP\CAN;..\BSP\LED;..\CORE;..\FWLIB\inc;..\FWLIB\src;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\BSP\TIMER;..\BSP\UW;..\BSP\KEY;..\BSP\USART2;..\DSP_LIB;..\DSP_LIB\Include;..\My_lib\Include;..\My_lib\Location
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group My_lib
    ../My_lib/Include/: Include.c
    ../My_lib/Location/: Location.c
  group BSP
    ../BSP/LED/: led.c
    ../BSP/TIMER/: timer.c
    ../BSP/UW/: UW.c
    ../BSP/KEY/: key.c
    ./: read.txt
    ../BSP/USART2/: USART2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group DIP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
